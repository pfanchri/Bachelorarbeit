# Keil uVision project vadc_measurement.uvprojx, settings and files
target vadc_measurement (5060020::V5.06 (build 20)::ARMCC)
  device: XMC4800-F144x1536 Infineon
  pack: Infineon.XMC4000_DFP.2.4.0
  cpu: IROM(0x08000000,0x180000) IROM2(0x0C000000,0x180000) IRAM(0x20000000,0x2CFC0) IRAM2(0x1FFE8000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: vadc_measurement
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT5: ROM 0xc000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x2cfc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  group Source
    ../: main.c
  group Doc
    ./: Readme.txt
software components: CMSIS:CORE 4.2.0, Device:Startup 1.5.0, Device:XMClib:GPIO 2.1.0, Device:XMClib:SCU 2.1.0, Device:XMClib:UART 2.1.0, Device:XMClib:VADC 2.1.0
